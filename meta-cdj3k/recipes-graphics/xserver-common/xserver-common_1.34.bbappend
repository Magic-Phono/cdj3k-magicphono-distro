FILESEXTRAPATHS_prepend :="${THISDIR}/${PN}:"

RDEPENDS_${PN} = "xmodmap xrandr xdpyinfo fbset"

