SRC_URI_prepend = "git://github.com/systemd/systemd.git;protocol=git \
                    "

