PV = "v19+svnr1919"

SRC_URI = "http://www.portaudio.com/archives/pa_stable_v19_20140130.tgz"
SRC_URI[md5sum] = "7f220406902af9dca009668e198cbd23"
SRC_URI[sha256sum] = "8fe024a5f0681e112c6979808f684c3516061cc51d3acc0b726af98fc96c8d57"

S = "${WORKDIR}/portaudio"
