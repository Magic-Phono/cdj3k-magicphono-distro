SRC_URI_prepend = "https://mirrors.dotsrc.org/gcrypt/gnutls/v3.3/gnutls-${PV}.tar.xz "
