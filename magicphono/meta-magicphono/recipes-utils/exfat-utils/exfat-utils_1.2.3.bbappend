SRC_URI_prepend = "https://archive.ubuntu.com/ubuntu/pool/universe/e/exfat-utils/exfat-utils_1.2.3.orig.tar.gz"
