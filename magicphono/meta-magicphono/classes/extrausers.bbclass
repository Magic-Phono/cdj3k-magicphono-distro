INHERIT += "extrausers"
EXTRA_USERS_PARAMS = "\
    usermod -p '\$5\$F1StRJ0tK7dYYcLu\$7tUWzoAcC4SLbdZKinlhem.dACSntZMqMW4kZKpBuV9' root; \
    "
