SRC_URI_prepend = "https://dev.gateworks.com/sources/v4l-utils-${PV}.tar.bz2 \
                    "
